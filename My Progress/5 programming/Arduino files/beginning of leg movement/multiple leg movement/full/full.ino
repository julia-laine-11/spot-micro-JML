// recovered 5/13
// contained sit/stand/walkRF/wallLF

#include <Servo.h>
#include <LiquidCrystal.h> // includes the LiquidCrystal Library 


LiquidCrystal lcd(22, 24, 26, 28, 30, 32); //     rs, enable, d4, d5, d6, d7

Servo tlf, tlb, trf, trb;
Servo mlf, mlb, mrf, mrb;
Servo slf, slb, srf, srb;

#define trig1 A2
#define trig2 A4
#define echo1 A3
#define echo2 A5


void setup() {
  lcd.begin(16,2); 
  lcd.print("poop"); 
  lcd.setCursor(2,1); 
  lcd.print("haha"); 

  Serial.begin(9600);
  pinMode(trig1, OUTPUT);
  pinMode(trig2, OUTPUT);
  pinMode(echo1, INPUT);
  pinMode(echo2, INPUT);

  tlf.attach(3);
  tlb.attach(9);
  trf.attach(6);
  trb.attach(12);

  mlf.attach(4);
  mlb.attach(13);
  mrf.attach(7);
  mrb.attach(10);

  slf.attach(5);
  slb.attach(11);
  srf.attach(8);
  srb.attach(2);

  stand();  

  slf.write(95);
  slb.write(85);
  srf.write(85);
  srb.write(110);  
}

void stat(int amt, int del, int pin){
  for(amt; 1 <= amt; amt --){
  digitalWrite(pin,HIGH);
  delay(100);
  digitalWrite(pin,LOW);
  delay(250);
  }
  delay(del * 1000);
}


float sensor1(){//get distance from ultrasonic sensor.
  digitalWrite(trig1, LOW);
  delayMicroseconds(2);
  digitalWrite(trig1,HIGH);
  delayMicroseconds(10);
  digitalWrite(trig1,LOW);
  delayMicroseconds(2);//These first lines generate the ultrasonic pulse. Found this code 4 years ago. Always has worked. I did the math on it a while ago to see why it worked, but I don't remember it off the top of my head, and it doesn't matter anyways.
  float time=pulseIn(echo1,HIGH);//listen for pulse to return
  float distance = time*340/20000;//calculate distance from surface in centimeters.
  return distance;//return distance in centimeters.
}

float sensor2(){//identical to first function, for the second sensor.
  digitalWrite(trig2, LOW);
  delayMicroseconds(2);
  digitalWrite(trig2,HIGH);
  delayMicroseconds(10);
  digitalWrite(trig2,LOW);
  delayMicroseconds(2);
  float time=pulseIn(echo2,HIGH);
  float distance = time*340/20000;
  return distance;
}


void stand(){
  mlf.write(90);
  mrf.write(90);
  delay(10);
  tlf.write(120);
  trf.write(60); 
  delay(1000);
  
  mlb.write(90);
  mrb.write(90);
  delay(10);
  tlb.write(120);
  trb.write(60);
   
  delay(1000);
}

void sit(){
  mrb.write(175);
  mlb.write(0);
  delay(10);
  tlb.write(175);
  trb.write(0);
  delay(1000);

  trf.write(0);
  tlf.write(175);
  delay(10);
  mrf.write(175);
  mlf.write(0);
  
  delay(5000);  
}



//////////////////////////////////////////////////////// issue: mid arms too far forward - need to get closer to rest position for better walking
void walketh(String side){                                      // be sure to change both functions when you change this*****
  int tla = 180; //left top angle
  int mla = 5; // left mid angle
  int tra = 0; // right top angle
  int mra = 175; // right mid angle

  if(side=="r" or side=="right"){
  for(int i=11;i>1;i--){    //    120 , 90 > 160 , 90
    tla += 4;
    tra -= 4;                   
    tlb.write(tla-10);   
    trf.write(tra+15);
    delay(10);        
  }

  for(int i=5;i>1;i--){    // 160 , 90 > 170 , 0
    tla += 1;
    tra -= 1;

    
    mlb.write(mla);
    mrf.write(mra);
    
    mla -= 11;
    mra += 11;

    tlb.write(tla-10);
    trf.write(tra+15);
    
    delay(10);
  }

  for(int i=15;i>1;i--){    // 170 , 0 > ~40 , 90
    tla -= 5;
    tra += 5;
       
    mlb.write(mla);
    mrf.write(mra);
    mla += 6;
    mra -= 6;

    tlb.write(tla-10);
    trf.write(tra+15);
     
    delay(10);
  }

  for(int i=5;i>1;i--){  // ~40 , 90 > 50 , 0
    tla += 5;
    tra -= 5;
    tlb.write(tla-10);
    trf.write(tra+15);
    delay(10);
    }
  }

   else{
   for(int i=11;i>1;i--){    //    120 , 90 > 160 , 90
    tla += 4;
    tra -= 4;                   
    tlf.write(tla-15);   
    trb.write(tra+15);
    delay(10);        
  }

  for(int i=5;i>1;i--){    // 160 , 90 > 170 , 0
    tla += 1;
    tra -= 1;
    
    mlf.write(mla);
    mrb.write(mra);
    mla -= 11;
    mra += 11;

    tlf.write(tla-15);
    trb.write(tra+15);
    
    delay(10);
  }

  for(int i=15;i>1;i--){    // 170 , 0 > ~40 , 90
    tla -= 5;
    tra += 5;
    
    mlf.write(mla);
    mrb.write(mra);
    mla += 6;
    mra -= 6;

    tlf.write(tla-15);
    trb.write(tra+15);
        
   
    delay(10);
    }

  for(int i=5;i>1;i--){  // ~40 , 90 > 50 , 0
    tla += 5;
    tra -= 5;
    tlf.write(tla-15);
    trb.write(tra+15);
    delay(10);
    }
  }
}



void loop() {  
 
  if(sensor1() > 25 && sensor2() > 0){
  walketh("r");
  walketh("l");
  digitalWrite(40,HIGH);
 }
 else{
  digitalWrite(40,LOW);
 }

  Serial.print("Sensor 1: ");
  Serial.print(sensor1());//uses functions to get distance
  Serial.print(" cm     ");
  Serial.print("Sensor 2: ");
  Serial.print(sensor2());
  Serial.println(" cm");
 
  

}
